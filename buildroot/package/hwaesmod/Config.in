## buildroot/package/hwaesmod/Config.in
```kconfig
config BR2_PACKAGE_HWAESMOD
	bool "hwaesmod"
	help
	  kernel module for aes core
```
